* Simple MNA demo
R1 1 2 5
R2 2 0 10
I1 2 0 1
V1 1 0 1
